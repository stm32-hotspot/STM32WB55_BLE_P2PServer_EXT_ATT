<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32WB55_BLE_P2PServer_EXT_ATT.ewp</path>
  </project>
  <batchBuild />
</workspace>
